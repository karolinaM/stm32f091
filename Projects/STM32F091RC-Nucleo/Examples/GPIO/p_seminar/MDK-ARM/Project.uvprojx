# Keil uVision project Project.uvprojx, settings and files
target STM32F091RC-Nucleo (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F091RC-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F091xC,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F0xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\Sensors\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2c.c
  group Example/MDK-ARM
    ./: startup_stm32f091xc.s
  group Example/User
    ../Src/: main.c stm32f0xx_it.c timer.c gpio.c i2c.c
  group Drivers/Sensors
    ../../../../../../Drivers/Sensors/src/: BH1750FVI.c
